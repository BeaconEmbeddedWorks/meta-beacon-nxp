FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://gattool.patch"
