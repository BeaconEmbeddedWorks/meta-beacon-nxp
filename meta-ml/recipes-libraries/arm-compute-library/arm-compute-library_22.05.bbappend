SRCBRANCH = "lf-6.1.55_2.2.0"
SRCREV = "37fc035060646db5048648da01db3738f08e3bfa"

EXTRA_OESCONS:append = "extra_cxx_flags='-fPIC -Wno-error=strict-overflow -Wno-error=array-bounds '"
SCONS_MAXLINELENGTH = ""

