# Copyright (C) 2020 Compass Electronics Group, LLC

DESCRIPTION = "Modified ts.conf to fix ts_test"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"


