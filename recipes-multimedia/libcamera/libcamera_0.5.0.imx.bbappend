COMPATIBLE_MACHINE = "(mx95-nxp-bsp|mx8mm-nxp-bsp|mx8mn-nxp-bsp|mx8mp-nxp-bsp|mx8ulp-nxp-bsp|mx8mq-nxp-bsp)"
