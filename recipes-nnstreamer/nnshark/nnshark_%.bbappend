NNSHARK_SRC = "git://github.com/nxp-imx/nnshark.git;protocol=https"

do_configure[network] = "1"
