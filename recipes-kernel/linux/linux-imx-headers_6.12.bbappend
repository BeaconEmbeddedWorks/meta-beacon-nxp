LINUX_IMX_SRC = "git://github.com/BeaconEmbeddedWorks/linux-imx.git;protocol=https;branch=${SRCBRANCH}"
SRCBRANCH = "lf-6.12.y-bcn"
SRCREV = "7703ba0910e84c0a80567c525c4a9d49dcb46276"
