#LINUX_IMX_SRC = "git://github.com/aford173/linux.git;protocol=https;branch=${SRCBRANCH}"
LINUX_IMX_SRC = "git://git@gitlab.logicpd.com/products/linux-imx-private.git;protocol=ssh;branch=${SRCBRANCH}"
SRCBRANCH = "6.12-merge"
SRCREV = "c6d635cc6e33437086ad5e353ff625d7b8cbea0a"

