# Disable Jitter because we have hwrng
PACKAGECONFIG ??= "none"
