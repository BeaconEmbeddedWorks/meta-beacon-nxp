SRC_URI = "git://github.com/BeaconEmbeddedWorks/imx-atf.git;protocol=https;branch=${SRCBRANCH}"
SRCBRANCH = "lf_v2.12-bcn"
SRCREV = "3a1b1c87b3f12e8a3aa0986ba6b36118d2405a8a"

