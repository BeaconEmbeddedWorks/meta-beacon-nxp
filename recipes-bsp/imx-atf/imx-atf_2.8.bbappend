ATF_SRC = "git://github.com/nxp-imx/imx-atf.git;protocol=https"
SRCBRANCH = "lf_v2.8"
SRCREV = "8dbe28631802a51b3ec8179b2c5635b00393ad97"
