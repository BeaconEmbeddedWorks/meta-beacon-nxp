SRC_URI = "git://github.com/aford173/atf.git;protocol=https;branch=${SRCBRANCH}"
SRCBRANCH = "v2.10-nxp"
SRCREV = "d7da75fef3623327553a7c0b9507d345a111bcd9"

