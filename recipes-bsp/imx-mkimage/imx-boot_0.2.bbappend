SOC_TARGET_mx8mn  = "iMX8MN"

ATF_MACHINE_NAME_mx8mn = "bl31-imx8mn.bin"

BOOT_STAGING_mx8mn = "${S}/iMX8M"


