UBOOT_SRC = "git://github.com/BeaconEmbeddedWorks/u-boot-imx.git;protocol=https"
SRCBRANCH = "lf_v2025.04-bcn"
SRCREV = "b81541f1db16de64e36d4a00cae36a9035d500c1"

