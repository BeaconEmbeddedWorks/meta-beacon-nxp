SRC_URI = "git://github.com/BeaconEmbeddedWorks/u-boot-imx.git;protocol=https;branch=${SRCBRANCH}"
SRCBRANCH = "bcn_lf_v2024.04-imx93"
SRCREV = "b1082bf3dd2c6960736f577d1debd38cd8fc67c5"
