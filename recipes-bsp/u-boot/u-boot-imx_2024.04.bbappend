
UBOOT_SRC = "git://github.com/aford173/u-boot.git;protocol=https"
SRCBRANCH = "lf_v2024.04-bcn"
SRCREV = "fa31ace536f6bc610614984fa687952055c3efd9"

